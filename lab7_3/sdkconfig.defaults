## lab7_3/sdkconfig.defaults
```kconfig
CONFIG_EXAMPLE_WIFI_SSID="Calvin iPhone"
CONFIG_EXAMPLE_WIFI_PASSWORD="calvinepix"
```
